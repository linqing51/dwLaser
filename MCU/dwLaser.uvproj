# Keil uVision project dwLaser.uvproj, settings and files
target Debug (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: dwLaser +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Source\Driver;.\Source\Lib;.\Source\MainApp;.\Source\Modbus;.\Source\uCos
  group uCos
    ./Source/uCos/: OS_CORE.C OS_CPU_C.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C OS_CPU_A.ASM
  group MainApp
    ./Source/MainApp/: MainApp.c InitConfig.c
  group Driver
    ./Source/Driver/: chipAdc.c chipPca.c chipSmb.c eprom.c i2c_bus.c
