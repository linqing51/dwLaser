# Keil uVision project bootloader.uvproj, settings and files
target Debug (MCS-51)
  device: C8051F120 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: bootloader +hex
  c flags: Optimize=8
  c define: C8051F120
  c include: .\Lib;.\OnChipFlash;.\UsbHost;.\Eprom;.\MainApp
  group Lib
    ./Lib/: crc16.c delay.c STARTUP.A51
  group OnChipFlash
    ./OnChipFlash/: F120_FlashPrimitives.c F120_FlashUtils.c
  group UsbHost
    ./UsbHost/: FILE_SYS.C usbSpi.C
  group SimEprom
    ./SimEprom/: eeprom.c flash.c
  group MainApp
    ./MainApp/: Bootloader.c InitDevice.c Fxxx_TargetBL_InfoBlock.c
