# Keil uVision project Bootloader.uvproj, settings and files
target Debug (MCS-51)
  device: C8051F340 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: bootload +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: C8051F340
  c include: .\Lib;.\LibFlash;.\FlashEprom;.\Bootloader;.\Driver
  group Lib
    ./Lib/: crc32.c L51_BANK.A51
  group LibFlash
    ./LibFlash/: F340_FlashPrimitives.c F340_FlashUtils.c
  group FlashEprom
    ./FlashEprom/: Fxxx_EEPROM_Interface.c Fxxx_Flash_Interface.c
  group Bootloader
    ./Bootloader/: Bootloader.c
