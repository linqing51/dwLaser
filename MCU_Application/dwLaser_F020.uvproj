# Keil uVision project dwLaser_F020.uvproj, settings and files
target Debug (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: dwLaser_F020 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib;.\Driver;.\MainApp;.\Modbus
  group Lib
    ./Lib/: delay.c crc32.c md5.c
  group Driver
    ./Driver/: i2c0.c i2c1.c i2c2.c i2c3.c i2c4.c i2c5.c i2c6.c eprom.c outPca9554.c inPca9554.c mcp47x6.c
  group Modbus
    ./Modbus/: modbusSlaveAscii.c
  group MainApp
    ./MainApp/: MainApp.c InitConfig.c sPlc.c ladder.c
