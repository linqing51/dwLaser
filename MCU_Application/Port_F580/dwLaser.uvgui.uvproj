# Keil uVision project dwLaser.uvgui.uvproj, settings and files
target F580 (MCS-51)
  device: C8051F580 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0-0x1FFF)  IROM(0-0x1FFFF) CLOCK(50000000)
  output: dwLaser.uvgui +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: C8051F580
  c include: ..\Lib;..\Driver;..\sPlc;..\sPlc\Modbus;..\sPlc\Port_f580
  group Lib
    ../Lib/: STARTUP.A51 delay.c
  group Driver
    ../Driver/: eprom.c i2c0.c i2c1.c i2c2.c i2c3.c i2c4.c i2c5.c i2c6.c inPca9554.c mcp47x6.c outPca9554.c
  group sPlc
    ../sPlc/: sPlcFun.c sPlc.c
  group sPlc_F580
    ../sPlc/Port_f580/: sPlcChipAdc.c sPlcDac.c sPlcInt.c sPlcIo.c sPlcLaser.c sPlcLed.c sPlcNvram.c sPlcTimer.c sPlcUart.c sPlcWatchDog.c
  group sPlc_Modbus
    ../sPlc/Modbus/: Modbus.c ModbusPort.c
  group MainApp
    ./: InitDeviceF580.c MainApp.c
