# Keil uVision project dwLaser.uvgui.uvproj, settings and files
target F020 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: dwLaser.uvgui +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: C8051F020
  c include: .\Lib;.\Driver;.\sPlc;.\sPlc\Modbus;.\sPlc\Port_f020;.\MainApp
  group Lib
    ./Lib/: STARTUP.A51 crc32.c delay.c
  group sPlc
    ./sPlc/: sPlc.c sPlcFun.c sPlcTest.c
  group sPlc_F020
    ./sPlc/Port_f020/: sPlcInt.c sPlcTimer.c
  group MainApp
    ./MainApp/: MainApp.c InitDeviceF020.c
target F580 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: dwLaser.uvgui
  c flags: Optimize=8 SizeSpeed=1
