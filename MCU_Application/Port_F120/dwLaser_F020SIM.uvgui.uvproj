# Keil uVision project dwLaser_F020SIM.uvgui.uvproj, settings and files
target F120 (MCS-51)
  device: C8051F120 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: dwLaser.uvgui +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: C8051F120
  c include: ..\Lib;..\Driver;..\sPlc;..\Port_F020;..\MainApp
  group Lib
    ../Lib/: delay.c crc32.c
  group Driver
    ../Driver/: epromSimulation.c
  group sPlc
    ../sPlc/: sPlc.c sPlcFun.c sPlcTest.c sPlcModbus.c
  group sPlc_F120
    ./: InitDevice.c sPlcTimer.c sPlcModbusPort.c sPlcLed.c sPlcUart.c sPlcMcu.c sPlcLaser.c
  group MainApp
    ../MainApp/: MainApp.c pidFuzzy.c
