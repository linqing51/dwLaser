# Keil uVision project dwLaser_F120.uvgui.uvproj, settings and files
target F120 (MCS-51)
  device: C8051F120 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: dwLaser.uvgui
  c flags: Optimize=8 SizeSpeed=1
  c define: C8051F120
  c include: ..\Lib;..\Driver;..\NfcLibrary;..\NfcLibrary\inc;..\NfcLibrary\NdefLibrary\inc;..\NfcLibrary\NxpNci\inc;..\sPlc;..\Port_F120;.\UsbHost;.\SimEprom;.\OnChipFlash;..\MainApp
  group Lib
    ../Lib/: delay.c crc32.c crc16.c
  group Drive
    ../Driver/: i2c0.c i2c1.c i2c2.c i2c3.c eprom.c debugLed.c
  group sPlc
    ../sPlc/: sPlc.c sPlcFun.c sPlcModbus.c sPlcFunEPID.c
  group sPlc_F120
    ./: InitDevice.c sPlcTimer.c sPlcMcu.c sPlcUart.c sPlcModbusPort.c sPlcIo.c sPlcChipAdc.c sPlcChipDac.c sPlcLaser.c sPlcPac.c sPlcSimEprom.c
  group MainApp
    ../MainApp/: MainApp.c backApp.c hmiApp.c
  group sPlc_F120_OnChipFlash
    ./OnChipFlash/: F120_FlashPrimitives.c F120_FlashUtils.c
  group sPlc_F120_SimEprom
    ./SimEprom/: eeprom.c flash.c
