# Keil uVision project dwLaser.uvgui.uvproj, settings and files
target C8051F0580 (MCS-51)
  device: C8051F580 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0-0x1FFF)  IROM(0-0x1FFFF) CLOCK(50000000)
  output: dwLaser_F020 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: C8051F580
  c include: .\Lib;.\Driver;.\MainApp;.\Modbus
  group Lib
    ./Lib/: delay.c crc32.c
  group Driver
    ./Driver/: i2c0.c eprom.c i2c1.c i2c2.c i2c3.c i2c4.c i2c5.c i2c6.c mcp47x6.c inPca9554.c outPca9554.c
  group Modbus
    ./Modbus/: Modbus.c ModbusPort.c
  group MainApp
    ./MainApp/: MainApp.c sPlc.c InitDeviceF020.c InitDeviceF580.c sPlcLaser.c
