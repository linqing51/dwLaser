# Keil uVision project dwLaser_F020SIM.uvgui.uvproj, settings and files
target F020 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: dwLaser.uvgui +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: C8051F020
  c include: ..\Lib;..\Driver;..\sPlc;..\Port_F020;..\MainApp
  group Lib
    ../Lib/: delay.c crc32.c
  group Driver
    ../Driver/: epromSimulation.c
  group sPlc
    ../sPlc/: sPlc.c sPlcFun.c sPlcTest.c sPlcModbus.c
  group sPlc_F020
    ./: InitDevice.c sPlcTimer.c sPlcModbusPort.c sPlcLed.c sPlcUart.c sPlcMcu.c
  group MainApp
    ../MainApp/: MainApp.c pidFuzzy.c
target F580 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: dwLaser.uvgui
  c flags: Optimize=8 SizeSpeed=1
